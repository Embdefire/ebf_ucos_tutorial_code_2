# Keil uVision project Fire_uCOS.uvprojx, settings and files
target Fire_μCOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_μCOS +hex
  c flags: Optim=2 oTime=1 OneElfS=1
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F7xx_HAL_Driver\Inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../User/: stm32f7xx_hal_conf.h
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c
  group USER_APP
    ../../User/APP/: main.c app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_app_hooks.c os_cfg_app.h os_app_hooks.h
    ../../User/BSP/: cpu_bsp.c
    ../../User/: stm32f7xx_it.c
  group BSP
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/usart/: bsp_debug_usart.c
    ../../User/BSP/key/: bsp_key.c
    ../../User/BSP/exti/: bsp_exti.c
  group μC/CPU
    ../../User/uC-CPU/Cache/ARM/armv7m_generic_l1/: cpu_cache_armv7m_generic_l1.c
    ../../User/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group μC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group μC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group μC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group DOC
    ../../Doc/: readme.txt
